# Keil uVision project W25QXX_V10.uvproj, settings and files
target W25QXX_V10 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: M25P64_STM3210E-EVAL
  AfterMake: cmd.exe /C copy "!L" "C:\Program Files (x86)\STMicroelectronics\@L.stldr"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Includes\Library_Files;..\..\Includes\Loader_Files;..\..\Includes\CMSIS_Files;..\..\Sources\Library_Files
  scatter file: Target.lin
  link misc: --diag_suppress L6305
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32F10x
    ../../Sources/Library_Files/: stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c stm32_eval_spi_flash.c stm32f10x_spi.c stm3210e_eval.c bsp_spi_flash.c stm32f10x_dma.c dma.c delay.c
